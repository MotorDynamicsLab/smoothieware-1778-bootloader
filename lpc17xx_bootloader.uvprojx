# Keil uVision project lpc17xx_bootloader.uvprojx, settings and files
target LPC1778 (ARM-ADS)
  device: LPC1778 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DFU-Bootloader +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf.exe --elf -o "$L@L.elf" "#L"
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: MAX_URI_LENGTH=512,__LPC177X_8X__,USB_DEVICE_ONLY,APPBAUD=115200,DEBUG_MESSAGES
  c misc: --gnu
  c include: CMSISv2p00_LPC17xx\inc;LPC177x_8xLib\inc;fatfs;.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group CMSIS
    ./CMSISv2p00_LPC17xx/src/: core_cm3.c system_LPC177x_8x.c startup_LPC177x_8x.s
  group LPCLIB
    ./LPC177x_8xLib/src/: lpc177x_8x_clkpwr.c lpc177x_8x_gpio.c lpc177x_8x_nvic.c lpc177x_8x_pinsel.c lpc177x_8x_ssp.c lpc177x_8x_systick.c lpc177x_8x_timer.c lpc177x_8x_uart.c lpc177x_8x_wwdt.c
  group fatfs
    ./fatfs/: diskio.c ff.c
    ./fatfs/option/: ccsbcs.c syscall.c unicode.c
  group bootloader
    ./: dfu.c gpio.c lpc177x_8x_usb.c main.c sbl_iap.c SDCard.c spi.c uart.c usbcore.c usbhw.c
target LPC1778-Release (ARM-ADS)
  device: LPC1778 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: as above
  output: lpc17xx_bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: MAX_URI_LENGTH=512,__LPC177X_8X__,USB_DEVICE_ONLY,APPBAUD=115200
  c misc: --gnu
  c include: .\CMSISv2p00_LPC17xx\inc;.\LPC177x_8xLib\inc;.\fatfs;.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
